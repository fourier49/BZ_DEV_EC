# Keil uVision project usbd_dfu_bw.uvprojx, settings and files
target USBD_DFU-STM32072B-EVAL (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F072B-EVAL +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STM32072B_EVAL,USE_STDPERIPH_DRIVER,STM32F072,USE_BIZLINK_VID_PID
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\Libraries\STM32_USB_Device_Library\Class\dfu\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32072B_EVAL;..\..\..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0xc0
  memory RVCT10: RAM 0x200000c4 size 0x3f40
  group App
    ../src/: app.c stm32_it.c usb_bsp.c usbd_desc.c usbd_pwr.c usbd_usr.c system_mode.c
  group USB_Class
    ../../../Libraries/STM32_USB_Device_Library/Class/dfu/src/: usbd_dfu_core.c usbd_dfu_mal.c usbd_flash_if.c
  group USB_Drivers
    ../../../Libraries/STM32_USB_Device_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_Library
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32F0XX
    ../src/: system_stm32f0xx.c
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s
  group STM32072B-EVAL
    ../../../Utilities/STM32_EVAL/STM32072B_EVAL/: stm32072b_eval.c
  group STM32F072_StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_crs.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_i2c.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_rtc.c
